# IAR project CMT2300A_Easy_Demo.ewp, settings and files
configuration STM32F051 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F051R8 ST STM32F051R8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F0XX_MD.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f051_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32F031 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F031C6 ST STM32F031C6
  OBJCOPY.OOCOutputFile: STM32F0XX_LD.hex
  ILINK.IlinkIcfFile: stm32f031_flash.icf
configuration STM32F072 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F072VB ST STM32F072VB
  ILINK.IlinkIcfFile: stm32f072_flash.icf
configuration STM32F030 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F030R8 ST STM32F030R8
  ICCARM.CCDefines: STM32F030; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..; ..\Radio\inc; ..\Libraries\CMSIS\Device\ST\STM32F0xx\Include
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkIcfFile: stm32f030_flash.icf
configuration STM32F042 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F042C6 ST STM32F042C6
  ILINK.IlinkIcfFile: stm32f042_flash.icf
configuration STM32F091 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F091VC ST STM32F091VC
  ILINK.IlinkIcfFile: stm32f091_flash.icf
configuration STM32F030xC (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F030RC ST STM32F030RC
  ILINK.IlinkIcfFile: stm32f030xc_flash.icf
configuration STM32F070x6 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F070C6 ST STM32F070C6
  ILINK.IlinkIcfFile: stm32f070x6_flash.icf
configuration STM32F070xB (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F070RB ST STM32F070RB
  ILINK.IlinkIcfFile: stm32f070xb_flash.icf
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f030.s
    ../: system_stm32f0xx.c
  group Radio/inc
    ../Radio/inc/: cmt2300.h cmt2300_defs.h CMT2300_FrqSetTab.h cmt2300_hal.h cmt2300_params.h CMT230_params_RxTxTest.h cmt_spi3.h crc.h radio.h typedefs.h
  group Radio/src
    ../Radio/src/: cmt2300.c cmt2300_hal.c cmt_spi3.c crc.c radio.c
  group StdPeriph_Driver
    ../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group User
    ../: delay.c gpio.c main.c spi.c stm32f0xx_it.c
